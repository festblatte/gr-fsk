<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>10**(-snr/10.)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>snr</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>noise</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>100</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>fsk_clock_recovery_mm_ff</key>
<param><key>id</key><value>fsk_clock_recovery_mm_ff_0</value></param>
<param><key>gain_mu</key><value>0.1</value></param>
<param><key>gain_omega</key><value>0.01</value></param>
<param><key>mu</key><value>0</value></param>
<param><key>omega_relative_limit</key><value>0.01</value></param>
<param><key>omega</key><value>sps</value></param>
</block>
<block>
<key>fsk_fsk_demod_c_ff</key>
<param><key>id</key><value>fsk_fsk_demod_c_ff_0</value></param>
<param><key>f1</key><value>-50</value></param>
<param><key>f2</key><value>50</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sampPerSym</key><value>sps</value></param>
</block>
<block>
<key>fsk_fsk_mod_py_bc</key>
<param><key>id</key><value>fsk_fsk_mod_py_bc_0</value></param>
<param><key>sampPerSym</key><value>sps</value></param>
</block>
<block>
<key>fsk_fsk_snr_ff_f</key>
<param><key>id</key><value>fsk_fsk_snr_ff_f_0</value></param>
<param><key>omega</key><value>0.001</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>90</value></param>
<param><key>srate</key><value>100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>450</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>9000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>fsk_fsk_demod_c_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>fsk_clock_recovery_mm_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fsk_fsk_mod_py_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fsk_clock_recovery_mm_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fsk_clock_recovery_mm_ff_0</source_block_id><sink_block_id>fsk_fsk_snr_ff_f_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fsk_clock_recovery_mm_ff_0</source_block_id><sink_block_id>fsk_fsk_snr_ff_f_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fsk_fsk_demod_c_ff_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fsk_fsk_demod_c_ff_0</source_block_id><sink_block_id>fsk_clock_recovery_mm_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fsk_fsk_demod_c_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fsk_fsk_demod_c_ff_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fsk_fsk_demod_c_ff_0</source_block_id><sink_block_id>fsk_clock_recovery_mm_ff_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>fsk_fsk_demod_c_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fsk_fsk_mod_py_bc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fsk_fsk_snr_ff_f_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
